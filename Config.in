## Config.in
```kconfig
config BR2_PACKAGE_BLINKPKG
	bool "blinkpkg"
	help
	  blinkpkg Raspberry Pi3b  blink example

	  https://github.com/svgliese/blink
```
